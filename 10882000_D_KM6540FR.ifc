Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-26T13:16:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 26 13:16:09 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{7CB20876-8C39-44A3-B997-A65B573BBC6C}\ifc * Database version: 5507 * Database creation date: Fri Apr 26 13:16:07 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 26 13:16:08 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 26 13:16:08 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26654010_D_10882000_KM6540FR, 10882000_D_KM6540FR:26654010_D_10882000_KM6540FR:204022
In: Level 1
Type - Classification: A-KM-7000 (Uniformat); Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_CLST, z_Miele_Connection_Electric, Default
Pset_BuildingElementProxyCommon - Reference: 26654010_D_10882000_KM6540FR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
